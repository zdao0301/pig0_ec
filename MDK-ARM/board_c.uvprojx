# Keil uVision project board_c.uvprojx, settings and files
target board_c (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: board_c +hex
  AfterMake: D:\keil\Postbuild\postbuild.bat "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USERCODE/robot_core;../lib/CMSIS-DSP/Include;../lib/CMSIS-DSP/Include/dsp;../USERCODE/robot_core/OS;../USERCODE/robot_core/OS/drv_freertos/include;C:/Keil_v5/ARM/ARMCC/include;../USERCODE/robot_core/OS/drv_freertos/portable/Keil
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c crc.c dma.c i2c.c rng.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group RobotConfig
    ../USERCODE/robot_core/: drv_conf.h
  group RobotCore/APP
    ../USERCODE/robot_core/APP/: robot.c behaviour.c boards_interact.c chassis.c gimbal.c shooter.h shooter17.c shooter42.c bus_detect.c fire_ctrl.c imu_bmi088.c pid_lpf_param.c ui_ctrl.c
  group RobotCore/Base
    ../USERCODE/robot_core/Base/: base_chassis.c base_gimbal.c drv_can.c drv_uart.c ext_imu.c bsp_dwt.c power_ctrl.c super_cap.c referee.c rc.c vision.c nav.c referee_conf.h
  group RobotCore/Base/UI
    ../USERCODE/robot_core/Base/UI/: priority_ui.c ui_def.c ui_protocol.c
  group RobotCore/Algorithm
    ../USERCODE/robot_core/Algorithm/: imu_calibrate.c imu_dcm.c imu_fusion.c imu_mahony.c matrix.c state_space.c VMC.c LQR.c MPC.c pid.c pid_ladrc.c pid_leso.c KF.c KF_DSP.c QuaternionEKF.c smc.c ramp.c OLS.c filter.c cordic.c ballistic.c referee_crc.c util.c CommonMacro.h pid_fuzzy.c
  group RobotCore/OS
    ../USERCODE/robot_core/OS/: robot_task.c
  group RobotCore/Tests
    ../USERCODE/robot_core/tests/: test.c
  group RobotCore/Tools
    ../USERCODE/robot_core/tools/: asr.c buzzer.c flash.c led.c vofa.c ws2812.c log.c
  group FreeRTOS/Core
    ../USERCODE/robot_core/OS/drv_freertos/: croutine.c event_groups.c list.c queue.c self_delay.c tasks.c timers.c
  group FreeRTOS/Pack
    ../USERCODE/robot_core/OS/drv_freertos/portable/MemMang/: heap_4.c
    ../USERCODE/robot_core/OS/drv_freertos/portable/Keil/: port.c
  group Devices/BMI088
    ../USERCODE/robot_core/Devices/BMI088/: bmi08a.c bmi08g.c drv_bmi088.c
  group Devices/MOTOR
    ../USERCODE/robot_core/Devices/MOTOR/: motor_ctrl.c motor_conf.h
    ../USERCODE/robot_core/Devices/MOTOR/motor_utils/: motor_math.c
    ../USERCODE/robot_core/Devices/MOTOR/motor_lib/: motor_ctrl_UT.c motor_ctrl_DM.c motor_ctrl_DM_QUAD.c motor_ctrl_RM_QUAD.c motor_ctrl_LK_QUAD.c
  group Lib/CMSISDSP
    ../lib/CMSIS-DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../lib/CMSIS-DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
software components: CMSIS:CORE 6.1.0
